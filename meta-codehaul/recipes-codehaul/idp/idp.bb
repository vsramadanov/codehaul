SUMMARY = "Identity provider"
DESCRIPTION = "Somehow provides identity and security tokens for authorized users"
LICENSE = "CLOSED"
